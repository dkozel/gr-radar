options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: simulator_fmcw_rcs
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 5.9e9
  states: {}
- name: decim_fac
  id: variable
  parameters:
    value: 2**5
  states: {}
- name: max_output_buffer
  id: variable
  parameters:
    value: '0'
  states: {}
- name: meas_duration
  id: variable
  parameters:
    value: (samp_cw+samp_up+samp_down)/float(samp_rate)
  states: {}
- name: m_min_output_buffer
  id: variable
  parameters:
    value: int((samp_up+samp_down+samp_cw)*2)
  states: {}
- name: protect_samp
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: range_res
  id: variable
  parameters:
    value: 3e8/2/sweep_freq
  states: {}
- name: rcs
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: samp_cw
  id: variable
  parameters:
    value: 2**14
  states: {}
- name: samp_down
  id: variable
  parameters:
    value: samp_up
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: samp_up
  id: variable
  parameters:
    value: 2**14
  states: {}
- name: sweep_freq
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-200'
    step: '1'
    stop: '0'
    value: '-200'
  states: {}
- name: v_res
  id: variable
  parameters:
    value: samp_rate/samp_cw*3e8/2/center_freq
  states: {}
- name: value_range
  id: variable_qtgui_range
  parameters:
    label: range
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '1000'
    value: '200'
  states: {}
- name: velocity
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '30'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '10e-9'
    minoutbuf: m_min_output_buffer
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    minoutbuf: m_min_output_buffer
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: m_min_output_buffer
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/(samp_cw/decim_fac)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/(samp_up/decim_fac)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/(samp_down/decim_fac)
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1.0/decim_fac
    lengthtagname: '"packet_len"'
    minoutbuf: m_min_output_buffer
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    minoutbuf: m_min_output_buffer
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decim_fac
    fc: '0'
    fftsize: samp_cw/decim_fac
    name: CW
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decim_fac
    fc: '0'
    fftsize: samp_up/decim_fac
    name: UP
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decim_fac
    fc: '0'
    fftsize: samp_up/decim_fac
    name: DOWN
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: radar_estimator_fmcw_0
  id: radar_estimator_fmcw
  parameters:
    center_freq: center_freq
    push_power: 'True'
    samp_down: samp_down//decim_fac
    samp_rate: samp_rate//decim_fac
    samp_up: samp_up//decim_fac
    sweep_freq: sweep_freq
  states: {}
- name: radar_estimator_rcs_0
  id: radar_estimator_rcs
  parameters:
    antenna_gain_rx: '0'
    antenna_gain_tx: '0'
    center_freq: center_freq
    corr_factor: '0.85'
    exponent: '1'
    num_mean: '10'
    power_tx: '1'
    usrp_gain_rx: '0'
  states: {}
- name: radar_find_max_peak_c_0
  id: radar_find_max_peak_c
  parameters:
    cut_max_freq: 'False'
    len_key: '"packet_len"'
    max_freq: '[]'
    samp_protect: protect_samp
    samp_rate: samp_rate//decim_fac
    threshold: threshold
  states: {}
- name: radar_find_max_peak_c_0_0
  id: radar_find_max_peak_c
  parameters:
    cut_max_freq: 'False'
    len_key: '"packet_len"'
    max_freq: '[]'
    samp_protect: protect_samp
    samp_rate: samp_rate//decim_fac
    threshold: threshold
  states: {}
- name: radar_find_max_peak_c_0_0_0
  id: radar_find_max_peak_c
  parameters:
    cut_max_freq: 'False'
    len_key: '"packet_len"'
    max_freq: '[]'
    samp_protect: protect_samp
    samp_rate: samp_rate//decim_fac
    threshold: threshold
  states: {}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {}
- name: radar_signal_generator_fmcw_c_0
  id: radar_signal_generator_fmcw_c
  parameters:
    amplitude: '1'
    freq_cw: '-sweep_freq/2'
    freq_sweep: sweep_freq
    len_key: '"packet_len"'
    minoutbuf: m_min_output_buffer
    samp_cw: samp_cw
    samp_down: samp_down
    samp_rate: samp_rate
    samp_up: samp_up
  states: {}
- name: radar_split_cc_0
  id: radar_split_cc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: m_min_output_buffer
    packet_num: '0'
    packet_parts: (samp_cw/decim_fac,samp_up/decim_fac,samp_down/decim_fac)
  states: {}
- name: radar_split_cc_0_0
  id: radar_split_cc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: m_min_output_buffer
    packet_num: '1'
    packet_parts: (samp_cw/decim_fac,samp_up/decim_fac,samp_down/decim_fac)
  states: {}
- name: radar_split_cc_0_0_0
  id: radar_split_cc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: m_min_output_buffer
    packet_num: '2'
    packet_parts: (samp_cw/decim_fac,samp_up/decim_fac,samp_down/decim_fac)
  states: {}
- name: radar_static_target_simulator_cc_0
  id: radar_static_target_simulator_cc
  parameters:
    azimuth: '0'
    center_freq: center_freq
    len_key: '"packet_len"'
    minoutbuf: m_min_output_buffer
    position_rx: '0'
    range: value_range
    rcs: rcs
    rndm_phaseshift: 'True'
    samp_rate: samp_rate
    self_coupling: 'True'
    self_coupling_db: '-10'
    velocity: velocity
  states: {}
- name: radar_ts_fft_cc_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: samp_cw//decim_fac
  states: {}
- name: radar_ts_fft_cc_0_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: samp_up//decim_fac
  states: {}
- name: radar_ts_fft_cc_0_1
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: samp_down//decim_fac
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', radar_find_max_peak_c_0, '0']
- [blocks_multiply_const_vxx_1, '0', radar_find_max_peak_c_0_0, '0']
- [blocks_multiply_const_vxx_2, '0', radar_find_max_peak_c_0_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', radar_split_cc_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', radar_split_cc_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', radar_split_cc_0_0_0, '0']
- [blocks_throttle_0, '0', radar_static_target_simulator_cc_0, '0']
- [radar_estimator_fmcw_0, Msg out, radar_estimator_rcs_0, Msg in]
- [radar_estimator_rcs_0, Msg out, radar_print_results_0, Msg in]
- [radar_find_max_peak_c_0, Msg out, radar_estimator_fmcw_0, Msg in CW]
- [radar_find_max_peak_c_0_0, Msg out, radar_estimator_fmcw_0, Msg in UP]
- [radar_find_max_peak_c_0_0_0, Msg out, radar_estimator_fmcw_0, Msg in DOWN]
- [radar_signal_generator_fmcw_c_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [radar_signal_generator_fmcw_c_0, '0', blocks_throttle_0, '0']
- [radar_split_cc_0, '0', qtgui_sink_x_0, '0']
- [radar_split_cc_0, '0', radar_ts_fft_cc_0, '0']
- [radar_split_cc_0_0, '0', qtgui_sink_x_0_0, '0']
- [radar_split_cc_0_0, '0', radar_ts_fft_cc_0_0, '0']
- [radar_split_cc_0_0_0, '0', qtgui_sink_x_0_0_0, '0']
- [radar_split_cc_0_0_0, '0', radar_ts_fft_cc_0_1, '0']
- [radar_static_target_simulator_cc_0, '0', blocks_add_xx_0, '1']
- [radar_ts_fft_cc_0, '0', blocks_multiply_const_vxx_0, '0']
- [radar_ts_fft_cc_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [radar_ts_fft_cc_0_1, '0', blocks_multiply_const_vxx_2, '0']
- [rational_resampler_xxx_0, '0', blocks_tagged_stream_multiply_length_0, '0']

metadata:
  file_format: 1
