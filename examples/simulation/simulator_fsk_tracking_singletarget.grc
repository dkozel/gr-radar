options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: simulator_fsk_tracking_singletarget
    output_language: python
  states: {}

blocks:
- name: R_max
  id: variable
  parameters:
    value: 3e8/2/delta_freq
  states: {}
- name: blocks_per_tag
  id: variable
  parameters:
    value: 2**17
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: decimator_fac
  id: variable
  parameters:
    value: 2**7
  states: {}
- name: delta_freq
  id: variable
  parameters:
    value: samp_rate/4
  states: {}
- name: freq_res
  id: variable
  parameters:
    value: samp_rate/2/blocks_per_tag
  states: {}
- name: m_min_output_buffer
  id: variable
  parameters:
    value: 2*(blocks_per_tag*samp_per_freq*2)
  states: {}
- name: range_time
  id: variable
  parameters:
    value: '10'
  states: {}
- name: range_value
  id: variable_qtgui_range
  parameters:
    label: range
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '120'
    value: '10'
  states: {}
- name: samp_discard
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_per_freq
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: Threshold Peak detector
    orient: Qt.Horizontal
    start: '-200'
    step: '1'
    stop: '1000'
    value: '-120'
  states: {}
- name: v_res
  id: variable
  parameters:
    value: freq_res*3e8/2/center_freq
  states: {}
- name: velocity
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-30'
    step: '1'
    stop: '30'
    value: '20'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.5'
    minoutbuf: m_min_output_buffer
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    minoutbuf: m_min_output_buffer
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: m_min_output_buffer
  states: {}
- name: blocks_multiply_conjugate_cc_1
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: m_min_output_buffer
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1.0/decimator_fac
    lengthtagname: '"packet_len"'
    minoutbuf: m_min_output_buffer
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1.0/decimator_fac
    lengthtagname: '"packet_len"'
    minoutbuf: m_min_output_buffer
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    minoutbuf: m_min_output_buffer
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decimator_fac/2
    fc: '0'
    fftsize: blocks_per_tag/decimator_fac
    name: QT GUI Plot
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: radar_estimator_fsk_0
  id: radar_estimator_fsk
  parameters:
    center_freq: center_freq
    delta_freq: delta_freq
    push_power: 'False'
  states: {}
- name: radar_find_max_peak_c_0
  id: radar_find_max_peak_c
  parameters:
    cut_max_freq: 'False'
    len_key: '"packet_len"'
    max_freq: '[]'
    samp_protect: '0'
    samp_rate: samp_rate//decimator_fac//2
    threshold: threshold
  states: {}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    filename: '"test.txt"'
    store_msg: 'False'
  states: {state: disabled}
- name: radar_qtgui_scatter_plot_0
  id: radar_qtgui_scatter_plot
  parameters:
    axis_x: '-10,120'
    axis_y: '-30,30'
    interval: '250'
    label_x: '''range'''
    label_y: '''velocity'''
  states: {state: disabled}
- name: radar_qtgui_time_plot_0
  id: radar_qtgui_time_plot
  parameters:
    axis_y: '-30,30'
    interval: '250'
    label: '"TRACKING"'
    label_y: '''velocity'''
    range_time: range_time
  states: {state: disabled}
- name: radar_qtgui_time_plot_0_0
  id: radar_qtgui_time_plot
  parameters:
    axis_y: '[0,R_max]'
    interval: '250'
    label: '"TRACKING"'
    label_y: '''range'''
    range_time: range_time
  states: {}
- name: radar_qtgui_time_plot_0_0_0
  id: radar_qtgui_time_plot
  parameters:
    axis_y: '[0,R_max]'
    interval: '250'
    label_y: '''range'''
    range_time: range_time
  states: {}
- name: radar_qtgui_time_plot_0_1
  id: radar_qtgui_time_plot
  parameters:
    axis_y: '-30,30'
    interval: '250'
    label_y: '''velocity'''
    range_time: range_time
  states: {state: disabled}
- name: radar_signal_generator_fsk_c_0
  id: radar_signal_generator_fsk_c
  parameters:
    amplitude: '1'
    blocks_per_tag: blocks_per_tag
    freq_high: delta_freq/2
    freq_low: '-delta_freq/2'
    len_key: '"packet_len"'
    minoutbuf: m_min_output_buffer
    samp_per_freq: samp_per_freq
    samp_rate: samp_rate
  states: {}
- name: radar_split_fsk_cc_0
  id: radar_split_fsk_cc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: m_min_output_buffer
    samp_discard: samp_discard
    samp_per_freq: samp_per_freq
  states: {}
- name: radar_static_target_simulator_cc_0
  id: radar_static_target_simulator_cc
  parameters:
    azimuth: '0'
    center_freq: center_freq
    len_key: '"packet_len"'
    minoutbuf: m_min_output_buffer
    position_rx: '0'
    range: range_value
    rcs: 1e16
    rndm_phaseshift: 'True'
    samp_rate: samp_rate
    self_coupling: 'True'
    self_coupling_db: '-10'
    velocity: velocity
  states: {}
- name: radar_tracking_singletarget_0
  id: radar_tracking_singletarget
  parameters:
    filter: '"particle"'
    num_particle: '100'
    std_accel_sys: '0.1'
    std_range_meas: '1'
    std_velocity_meas: v_res
    threshold_lost: '3'
    threshold_track: '0.001'
  states: {}
- name: radar_ts_fft_cc_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: blocks_per_tag//decimator_fac
  states: {}
- name: radar_ts_fft_cc_0_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: blocks_per_tag//decimator_fac
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimator_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: decimator_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_conjugate_cc_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', radar_find_max_peak_c_0, '0']
- [blocks_multiply_conjugate_cc_1, '0', radar_split_fsk_cc_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', qtgui_sink_x_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', radar_ts_fft_cc_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', radar_ts_fft_cc_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_conjugate_cc_1, '1']
- [blocks_throttle_0, '0', radar_static_target_simulator_cc_0, '0']
- [radar_estimator_fsk_0, Msg out, radar_qtgui_time_plot_0_0_0, Msg in]
- [radar_estimator_fsk_0, Msg out, radar_qtgui_time_plot_0_1, Msg in]
- [radar_estimator_fsk_0, Msg out, radar_tracking_singletarget_0, Msg in]
- [radar_find_max_peak_c_0, Msg out, radar_estimator_fsk_0, Msg in]
- [radar_signal_generator_fsk_c_0, '0', blocks_throttle_0, '0']
- [radar_split_fsk_cc_0, '0', rational_resampler_xxx_0, '0']
- [radar_split_fsk_cc_0, '1', rational_resampler_xxx_0_0, '0']
- [radar_static_target_simulator_cc_0, '0', blocks_add_xx_0, '1']
- [radar_tracking_singletarget_0, Msg out, radar_print_results_0, Msg in]
- [radar_tracking_singletarget_0, Msg out, radar_qtgui_time_plot_0, Msg in]
- [radar_tracking_singletarget_0, Msg out, radar_qtgui_time_plot_0_0, Msg in]
- [radar_ts_fft_cc_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [radar_ts_fft_cc_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [rational_resampler_xxx_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']

metadata:
  file_format: 1
