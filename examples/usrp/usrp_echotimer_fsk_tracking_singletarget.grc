options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: usrp_echotimer_fsk_tracking_singletarget
    output_language: python
  states: {}

blocks:
- name: block_per_tag
  id: variable
  parameters:
    value: 2**20
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '2450000000'
  states: {}
- name: decim_fac
  id: variable
  parameters:
    value: 2**12
  states: {}
- name: delay_samp
  id: variable_qtgui_range
  parameters:
    label: Number delay samples
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '39'
  states: {}
- name: delta_freq
  id: variable
  parameters:
    value: '11000000'
  states: {}
- name: fac_corr
  id: variable
  parameters:
    value: '2'
  states: {}
- name: freq_res
  id: variable
  parameters:
    value: samp_rate_red/float(packet_len_red)
  states: {}
- name: gain_rx
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    label: RX gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: gain_tx
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: TX gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: measure_time
  id: variable
  parameters:
    value: (block_per_tag*samp_per_freq*2)/float(samp_rate)
  states: {}
- name: m_min_output_buffer
  id: variable
  parameters:
    value: 2*samp_per_freq*block_per_tag*2
  states: {}
- name: packet_len_red
  id: variable
  parameters:
    value: block_per_tag//decim_fac
  states: {}
- name: range_res
  id: variable
  parameters:
    value: 3e8/2/delta_freq*fac_corr
  states: {}
- name: range_time
  id: variable
  parameters:
    value: '60'
  states: {}
- name: samp_per_freq
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_protect
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1
    label: Find peak protected samples
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: samp_rate_red
  id: variable
  parameters:
    value: samp_rate//2//samp_per_freq//decim_fac
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0
    label: Find peak threshold
    orient: Qt.Horizontal
    start: '-200'
    step: '1'
    stop: '100'
    value: '-200'
  states: {}
- name: vel_res
  id: variable
  parameters:
    value: freq_res/2.0/center_freq*3e8
  states: {}
- name: wait_to_start
  id: variable
  parameters:
    value: '0.02'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: m_min_output_buffer
  states: {}
- name: blocks_multiply_conjugate_cc_1
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: m_min_output_buffer//2//samp_per_freq//decim_fac
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1/float(decim_fac)
    lengthtagname: '"packet_len"'
    minoutbuf: m_min_output_buffer//samp_per_freq//2//decim_fac
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1/float(decim_fac)
    lengthtagname: '"packet_len"'
    minoutbuf: m_min_output_buffer//samp_per_freq//2//decim_fac
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_red
    fc: '0'
    fftsize: packet_len_red
    name: QT GUI Plot
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: radar_estimator_fsk_0
  id: radar_estimator_fsk
  parameters:
    center_freq: center_freq
    delta_freq: delta_freq/fac_corr
    push_power: 'False'
  states: {}
- name: radar_find_max_peak_c_0
  id: radar_find_max_peak_c
  parameters:
    cut_max_freq: 'False'
    len_key: '"packet_len"'
    max_freq: '[]'
    samp_protect: int(samp_protect)
    samp_rate: samp_rate_red
    threshold: threshold
  states: {}
- name: radar_print_results_1
  id: radar_print_results
  parameters:
    filename: '"store_msgs.txt"'
    store_msg: 'False'
  states: {}
- name: radar_qtgui_time_plot_0
  id: radar_qtgui_time_plot
  parameters:
    axis_y: '-3,3'
    interval: '100'
    label_y: '''velocity'''
    range_time: range_time
  states: {}
- name: radar_qtgui_time_plot_0_0
  id: radar_qtgui_time_plot
  parameters:
    axis_y: 0,15
    interval: '100'
    label_y: '''range'''
    range_time: range_time
  states: {}
- name: radar_qtgui_time_plot_0_0_1
  id: radar_qtgui_time_plot
  parameters:
    axis_y: 0,15
    interval: '100'
    label: '"TRACKING"'
    label_y: '''range'''
    range_time: range_time
  states: {}
- name: radar_qtgui_time_plot_0_1
  id: radar_qtgui_time_plot
  parameters:
    axis_y: '-3,3'
    interval: '100'
    label: '"TRACKING"'
    label_y: '''velocity'''
    range_time: range_time
  states: {}
- name: radar_signal_generator_fsk_c_0
  id: radar_signal_generator_fsk_c
  parameters:
    amplitude: '0.5'
    blocks_per_tag: block_per_tag
    freq_high: delta_freq/2
    freq_low: '-delta_freq/2'
    len_key: '"packet_len"'
    minoutbuf: m_min_output_buffer
    samp_per_freq: samp_per_freq
    samp_rate: samp_rate
  states: {}
- name: radar_split_fsk_cc_0
  id: radar_split_fsk_cc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: m_min_output_buffer//2
    samp_discard: samp_per_freq-1
    samp_per_freq: samp_per_freq
  states: {}
- name: radar_tracking_singletarget_0
  id: radar_tracking_singletarget
  parameters:
    filter: '"particle"'
    num_particle: '500'
    std_accel_sys: '2'
    std_range_meas: range_res/100
    std_velocity_meas: vel_res
    threshold_lost: '1'
    threshold_track: '0.001'
  states: {}
- name: radar_ts_fft_cc_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: packet_len_red
  states: {}
- name: radar_ts_fft_cc_0_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: packet_len_red
  states: {}
- name: radar_usrp_echotimer_cc_0
  id: radar_usrp_echotimer_cc
  parameters:
    antenna_rx: '''J1'''
    antenna_tx: '''J1'''
    args_rx: '''addr=192.168.10.6'''
    args_tx: '''addr=192.168.10.4'''
    center_freq: center_freq
    clock_source_tx: '''gpsdo'''
    gain_rx: gain_rx
    gain_tx: gain_tx
    minoutbuf: m_min_output_buffer
    num_delay_samps: int(delay_samp)
    samp_rate: samp_rate
    time_source_tx: '''gpsdo'''
    wait_rx: wait_to_start
    wait_tx: wait_to_start
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: decim_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_multiply_conjugate_cc_0, '0', radar_split_fsk_cc_0, '0']
- [blocks_multiply_conjugate_cc_1, '0', radar_find_max_peak_c_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', qtgui_sink_x_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', radar_ts_fft_cc_0_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', radar_ts_fft_cc_0, '0']
- [radar_estimator_fsk_0, Msg out, radar_print_results_1, Msg in]
- [radar_estimator_fsk_0, Msg out, radar_qtgui_time_plot_0, Msg in]
- [radar_estimator_fsk_0, Msg out, radar_qtgui_time_plot_0_0, Msg in]
- [radar_estimator_fsk_0, Msg out, radar_tracking_singletarget_0, Msg in]
- [radar_find_max_peak_c_0, Msg out, radar_estimator_fsk_0, Msg in]
- [radar_signal_generator_fsk_c_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [radar_signal_generator_fsk_c_0, '0', radar_usrp_echotimer_cc_0, '0']
- [radar_split_fsk_cc_0, '0', rational_resampler_xxx_0, '0']
- [radar_split_fsk_cc_0, '1', rational_resampler_xxx_0_0, '0']
- [radar_tracking_singletarget_0, Msg out, radar_qtgui_time_plot_0_0_1, Msg in]
- [radar_tracking_singletarget_0, Msg out, radar_qtgui_time_plot_0_1, Msg in]
- [radar_ts_fft_cc_0, '0', blocks_multiply_conjugate_cc_1, '1']
- [radar_ts_fft_cc_0_0, '0', blocks_multiply_conjugate_cc_1, '0']
- [radar_usrp_echotimer_cc_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [rational_resampler_xxx_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']

metadata:
  file_format: 1
