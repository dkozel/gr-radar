options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: usrp_echotimer_cw
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '2400000000'
  states: {}
- name: decim_fac
  id: variable
  parameters:
    value: 2**9
  states: {}
- name: freq_res
  id: variable
  parameters:
    value: samp_rate/float(packet_len)
  states: {}
- name: gain_rx
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    label: RX gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: gain_tx
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: TX gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: m_min_output_buffer
  id: variable
  parameters:
    value: packet_len*2
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: 2**16
  states: {}
- name: packet_len_red
  id: variable
  parameters:
    value: packet_len/decim_fac
  states: {}
- name: samp_protect
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0
    label: Number protected samples
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: t_measure
  id: variable
  parameters:
    value: packet_len/float(samp_rate)
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1
    label: Find peak treshold
    orient: Qt.Horizontal
    start: '-200'
    step: '1'
    stop: '100'
    value: '-200'
  states: {}
- name: wait_to_start
  id: variable
  parameters:
    value: '0.02'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: m_min_output_buffer
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1.0/decim_fac
    lengthtagname: '"packet_len"'
    minoutbuf: m_min_output_buffer
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decim_fac
    fc: '0'
    fftsize: packet_len/decim_fac
    name: QT GUI Plot
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decim_fac
    fc: '0'
    fftsize: packet_len//decim_fac
    name: QT GUI Plot
    plotconst: 'False'
    plottime: 'False'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decim_fac
    fc: '0'
    fftsize: packet_len/decim_fac
    name: QT GUI Plot
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: radar_estimator_cw_0
  id: radar_estimator_cw
  parameters:
    center_freq: center_freq
  states: {}
- name: radar_find_max_peak_c_0
  id: radar_find_max_peak_c
  parameters:
    cut_max_freq: 'False'
    len_key: '"packet_len"'
    max_freq: '[]'
    samp_protect: int(samp_protect)
    samp_rate: samp_rate//decim_fac
    threshold: threshold
  states: {}
- name: radar_os_cfar_c_0
  id: radar_os_cfar_c
  parameters:
    len_key: '"packet_len"'
    merge_consecutive: 'True'
    minoutbuf: m_min_output_buffer
    mult_threshold: '10'
    rel_threshold: '0.78'
    samp_compare: '5'
    samp_protect: '10'
    samp_rate: samp_rate/decim_fac
  states: {state: disabled}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {}
- name: radar_signal_generator_cw_c_0
  id: radar_signal_generator_cw_c
  parameters:
    amplitude: '0.5'
    frequency: '0'
    len_key: '"packet_len"'
    minoutbuf: m_min_output_buffer
    packet_len: packet_len
    samp_rate: samp_rate
  states: {}
- name: radar_ts_fft_cc_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: packet_len//decim_fac
  states: {}
- name: radar_usrp_echotimer_cc_0
  id: radar_usrp_echotimer_cc
  parameters:
    antenna_rx: '''J1'''
    antenna_tx: '''J1'''
    args_rx: '''addr=192.168.10.4'''
    args_tx: '''addr=192.168.10.6'''
    center_freq: center_freq
    gain_rx: gain_rx
    gain_tx: gain_tx
    minoutbuf: m_min_output_buffer
    num_delay_samps: '24'
    samp_rate: samp_rate
    wait_rx: wait_to_start
    wait_tx: wait_to_start
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_multiply_conjugate_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', qtgui_sink_x_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', radar_ts_fft_cc_0, '0']
- [radar_estimator_cw_0, Msg out, radar_print_results_0, Msg in]
- [radar_find_max_peak_c_0, Msg out, radar_estimator_cw_0, Msg in]
- [radar_os_cfar_c_0, Msg out, radar_estimator_cw_0, Msg in]
- [radar_signal_generator_cw_c_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [radar_signal_generator_cw_c_0, '0', radar_usrp_echotimer_cc_0, '0']
- [radar_ts_fft_cc_0, '0', radar_find_max_peak_c_0, '0']
- [radar_ts_fft_cc_0, '0', radar_os_cfar_c_0, '0']
- [radar_usrp_echotimer_cc_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [rational_resampler_xxx_0, '0', blocks_tagged_stream_multiply_length_0, '0']

metadata:
  file_format: 1
