options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: usrp_echotimer_fmcw
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 5.9e9
  states: {}
- name: decim_fac
  id: variable
  parameters:
    value: 2**3
  states: {}
- name: delay_samp
  id: variable_qtgui_range
  parameters:
    label: Number delay samples
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '24'
  states: {}
- name: freq_res_cw
  id: variable
  parameters:
    value: samp_rate/samp_cw
  states: {}
- name: freq_res_up
  id: variable
  parameters:
    value: samp_rate/samp_up
  states: {}
- name: max_output_buffer
  id: variable
  parameters:
    value: '0'
  states: {}
- name: meas_duration
  id: variable
  parameters:
    value: (samp_cw+samp_up+samp_down)/float(samp_rate)
  states: {}
- name: m_min_output_buffer
  id: variable
  parameters:
    value: int((samp_up+samp_down+samp_cw)*2)
  states: {}
- name: protect_samp
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: range_res
  id: variable
  parameters:
    value: 3e8/2/sweep_freq
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '30'
  states: {}
- name: samp_cw
  id: variable
  parameters:
    value: 2**14
  states: {}
- name: samp_down
  id: variable
  parameters:
    value: samp_up
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: samp_up
  id: variable
  parameters:
    value: 2**14
  states: {}
- name: sweep_freq
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0
    orient: Qt.Horizontal
    start: '-150'
    step: '1'
    stop: '0'
    value: '-150'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: TX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: v_res
  id: variable
  parameters:
    value: samp_rate/samp_cw*3e8/2/center_freq
  states: {}
- name: wait_to_start
  id: variable
  parameters:
    value: '0.02'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: m_min_output_buffer
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1.0/decim_fac
    lengthtagname: '"packet_len"'
    minoutbuf: m_min_output_buffer
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decim_fac
    fc: '0'
    fftsize: samp_cw/decim_fac
    name: CW
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decim_fac
    fc: '0'
    fftsize: samp_up//decim_fac
    name: UP
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decim_fac
    fc: '0'
    fftsize: samp_up//decim_fac
    name: DOWN
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: radar_estimator_fmcw_0
  id: radar_estimator_fmcw
  parameters:
    center_freq: center_freq
    push_power: 'False'
    samp_down: samp_down//decim_fac
    samp_rate: samp_rate//decim_fac
    samp_up: samp_up//decim_fac
    sweep_freq: sweep_freq
  states: {}
- name: radar_find_max_peak_c_0
  id: radar_find_max_peak_c
  parameters:
    cut_max_freq: 'False'
    len_key: '"packet_len"'
    max_freq: '[]'
    minoutbuf: m_min_output_buffer
    samp_protect: int(protect_samp)
    samp_rate: samp_rate//decim_fac
    threshold: threshold
  states: {}
- name: radar_find_max_peak_c_0_0
  id: radar_find_max_peak_c
  parameters:
    cut_max_freq: 'False'
    len_key: '"packet_len"'
    max_freq: '[]'
    minoutbuf: m_min_output_buffer
    samp_protect: int(protect_samp)
    samp_rate: samp_rate//decim_fac
    threshold: threshold
  states: {}
- name: radar_find_max_peak_c_0_0_0
  id: radar_find_max_peak_c
  parameters:
    cut_max_freq: 'False'
    len_key: '"packet_len"'
    max_freq: '[]'
    minoutbuf: m_min_output_buffer
    samp_protect: int(protect_samp)
    samp_rate: samp_rate//decim_fac
    threshold: threshold
  states: {}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {state: disabled}
- name: radar_signal_generator_fmcw_c_0
  id: radar_signal_generator_fmcw_c
  parameters:
    amplitude: '1'
    freq_cw: '-sweep_freq/2'
    freq_sweep: sweep_freq
    len_key: '"packet_len"'
    minoutbuf: m_min_output_buffer
    samp_cw: samp_cw
    samp_down: samp_down
    samp_rate: samp_rate
    samp_up: samp_up
  states: {}
- name: radar_split_cc_0
  id: radar_split_cc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: m_min_output_buffer
    packet_num: '0'
    packet_parts: (samp_cw/decim_fac,samp_up/decim_fac,samp_down/decim_fac)
  states: {}
- name: radar_split_cc_0_0
  id: radar_split_cc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: m_min_output_buffer
    packet_num: '1'
    packet_parts: (samp_cw/decim_fac,samp_up/decim_fac,samp_down/decim_fac)
  states: {}
- name: radar_split_cc_0_0_0
  id: radar_split_cc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: m_min_output_buffer
    packet_num: '2'
    packet_parts: (samp_cw/decim_fac,samp_up/decim_fac,samp_down/decim_fac)
  states: {}
- name: radar_ts_fft_cc_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: samp_cw//decim_fac
  states: {}
- name: radar_ts_fft_cc_1
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: samp_up//decim_fac
  states: {}
- name: radar_ts_fft_cc_2
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: samp_down//decim_fac
  states: {}
- name: radar_usrp_echotimer_cc_0
  id: radar_usrp_echotimer_cc
  parameters:
    antenna_rx: '''J1'''
    antenna_tx: '''J1'''
    args_rx: '''addr=192.168.10.4'''
    args_tx: '''addr=192.168.10.6'''
    center_freq: center_freq
    gain_rx: rx_gain
    gain_tx: tx_gain
    minoutbuf: m_min_output_buffer
    num_delay_samps: int(delay_samp)
    samp_rate: samp_rate
    wait_rx: wait_to_start
    wait_tx: wait_to_start
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_multiply_conjugate_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', radar_split_cc_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', radar_split_cc_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', radar_split_cc_0_0_0, '0']
- [radar_estimator_fmcw_0, Msg out, radar_print_results_0, Msg in]
- [radar_find_max_peak_c_0, Msg out, radar_estimator_fmcw_0, Msg in CW]
- [radar_find_max_peak_c_0_0, Msg out, radar_estimator_fmcw_0, Msg in UP]
- [radar_find_max_peak_c_0_0_0, Msg out, radar_estimator_fmcw_0, Msg in DOWN]
- [radar_signal_generator_fmcw_c_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [radar_signal_generator_fmcw_c_0, '0', radar_usrp_echotimer_cc_0, '0']
- [radar_split_cc_0, '0', qtgui_sink_x_0, '0']
- [radar_split_cc_0, '0', radar_ts_fft_cc_0, '0']
- [radar_split_cc_0_0, '0', qtgui_sink_x_0_0, '0']
- [radar_split_cc_0_0, '0', radar_ts_fft_cc_1, '0']
- [radar_split_cc_0_0_0, '0', qtgui_sink_x_0_0_0, '0']
- [radar_split_cc_0_0_0, '0', radar_ts_fft_cc_2, '0']
- [radar_ts_fft_cc_0, '0', radar_find_max_peak_c_0, '0']
- [radar_ts_fft_cc_1, '0', radar_find_max_peak_c_0_0, '0']
- [radar_ts_fft_cc_2, '0', radar_find_max_peak_c_0_0_0, '0']
- [radar_usrp_echotimer_cc_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [rational_resampler_xxx_0, '0', blocks_tagged_stream_multiply_length_0, '0']

metadata:
  file_format: 1
