options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: usrp_echotimer_sync_pulse
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '2400000000'
  states: {}
- name: m_min_output_buffer
  id: variable
  parameters:
    value: packet_len*2
  states: {}
- name: num_corr
  id: variable_qtgui_range
  parameters:
    label: Number of cross correlations
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: packet_len
    value: packet_len
  states: {}
- name: num_delay_samp
  id: variable_qtgui_range
  parameters:
    label: Number of delayed samples
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: packet_len
    value: '0'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: sum(wait_samp)+sum(send_samp)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '15000000'
  states: {}
- name: send_samp
  id: variable
  parameters:
    value: 100,400,300
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: wait_samp
  id: variable
  parameters:
    value: 100,100,100,100
  states: {}
- name: wait_to_start
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    name: QT GUI Plot
    nconnections: '2'
    size: packet_len
    srate: samp_rate
    type: float
  states: {}
- name: radar_estimator_sync_pulse_c_0
  id: radar_estimator_sync_pulse_c
  parameters:
    len_key: '"packet_len"'
    num_xcorr: int(num_corr)
  states: {}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {}
- name: radar_signal_generator_sync_pulse_c_0
  id: radar_signal_generator_sync_pulse_c
  parameters:
    len_key: '"packet_len"'
    minoutbuf: m_min_output_buffer
    packet_len: packet_len
    pulse_amplitude: '0.5'
    pulse_len: send_samp
    pulse_pause: wait_samp
  states: {}
- name: radar_usrp_echotimer_cc_0
  id: radar_usrp_echotimer_cc
  parameters:
    antenna_rx: '''J1'''
    antenna_tx: '''J1'''
    args_rx: '''addr=192.168.10.4'''
    args_tx: '''addr=192.168.10.6'''
    center_freq: center_freq
    gain_rx: rx_gain
    gain_tx: tx_gain
    minoutbuf: m_min_output_buffer
    num_delay_samps: int(num_delay_samp)
    samp_rate: samp_rate
    timeout_rx: '0.2'
    timeout_tx: '0.2'
    wait_rx: wait_to_start
    wait_tx: wait_to_start
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '''J1'''
    center_freq0: 2.4e9
    clock_rate: '0.0'
    dev_addr: '''addr=192.168.10.6'''
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: '''packet_len'''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '''J1'''
    center_freq0: 2.4e9
    clock_rate: '0.0'
    clock_source0: mimo
    dc_offs_enb0: '""'
    dev_addr: '''addr=192.168.10.4'''
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    time_source0: mimo
    type: fc32
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', radar_estimator_sync_pulse_c_0, '1']
- [radar_estimator_sync_pulse_c_0, Msg out, radar_print_results_0, Msg in]
- [radar_signal_generator_sync_pulse_c_0, '0', blocks_complex_to_mag_0_0, '0']
- [radar_signal_generator_sync_pulse_c_0, '0', radar_estimator_sync_pulse_c_0, '0']
- [radar_signal_generator_sync_pulse_c_0, '0', radar_usrp_echotimer_cc_0, '0']
- [radar_signal_generator_sync_pulse_c_0, '0', uhd_usrp_sink_0, command]
- [radar_usrp_echotimer_cc_0, '0', blocks_complex_to_mag_0, '0']
- [radar_usrp_echotimer_cc_0, '0', radar_estimator_sync_pulse_c_0, '1']
- [uhd_usrp_source_0, '0', blocks_stream_to_tagged_stream_0, '0']

metadata:
  file_format: 1
