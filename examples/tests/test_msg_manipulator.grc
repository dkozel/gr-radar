options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: test_msg_manipulator
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 5.7e9
  states: {}
- name: const_add
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '100'
    value: '-20'
  states: {}
- name: const_mult
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: decimator_fac
  id: variable
  parameters:
    value: 2**0
  states: {}
- name: freq
  id: variable
  parameters:
    value: (-10000,10000)
  states: {}
- name: freq_res
  id: variable
  parameters:
    value: samp_rate/float(packet_len)
  states: {}
- name: max_output_buffer
  id: variable
  parameters:
    value: '0'
  states: {}
- name: m_min_output_buffer
  id: variable
  parameters:
    value: int(packet_len*2)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: 2**15
  states: {}
- name: range_res
  id: variable
  parameters:
    value: 3e8/2/float((freq[1]-freq[0]))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: time_res
  id: variable
  parameters:
    value: packet_len/float(samp_rate)
  states: {}
- name: v_res
  id: variable
  parameters:
    value: freq_res*3e8/2/center_freq
  states: {}
- name: value_range
  id: variable_qtgui_range
  parameters:
    label: range
    orient: Qt.Horizontal
    start: '0'
    step: '100'
    stop: '10000'
    value: '2000'
  states: {}
- name: vel
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-50'
    step: '0.1'
    stop: '50'
    value: '50'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.5'
    maxoutbuf: max_output_buffer
    minoutbuf: m_min_output_buffer
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    maxoutbuf: max_output_buffer
    minoutbuf: m_min_output_buffer
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1/float(decimator_fac)
    lengthtagname: '"packet_len"'
    minoutbuf: m_min_output_buffer
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    maxoutbuf: max_output_buffer
    minoutbuf: m_min_output_buffer
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decimator_fac
    fc: '0'
    fftsize: packet_len//decimator_fac
    name: QT GUI Plot
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: radar_estimator_cw_0
  id: radar_estimator_cw
  parameters:
    center_freq: center_freq
  states: {}
- name: radar_msg_manipulator_0
  id: radar_msg_manipulator
  parameters:
    const_add: (const_add,)
    const_mult: (const_mult,)
    symbols: ('velocity',)
  states: {}
- name: radar_os_cfar_c_0
  id: radar_os_cfar_c
  parameters:
    len_key: '"packet_len"'
    merge_consecutive: 'True'
    minoutbuf: m_min_output_buffer
    mult_threshold: '20'
    rel_threshold: '0.78'
    samp_compare: '10'
    samp_protect: '0'
    samp_rate: samp_rate
  states: {}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {}
- name: radar_print_results_1
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {state: disabled}
- name: radar_qtgui_scatter_plot_0
  id: radar_qtgui_scatter_plot
  parameters:
    axis_x: '-50,50'
    axis_y: '-1,1'
    interval: '250'
    label_x: '''velocity'''
    label_y: '''y'''
  states: {state: disabled}
- name: radar_qtgui_time_plot_0
  id: radar_qtgui_time_plot
  parameters:
    axis_y: '-50,50'
    interval: '250'
    label_y: '''velocity'''
    range_time: '10'
  states: {state: disabled}
- name: radar_signal_generator_cw_c_0
  id: radar_signal_generator_cw_c
  parameters:
    amplitude: '1'
    frequency: freq
    len_key: '"packet_len"'
    maxoutbuf: max_output_buffer
    minoutbuf: m_min_output_buffer
    packet_len: packet_len
    samp_rate: samp_rate
  states: {}
- name: radar_static_target_simulator_cc_0
  id: radar_static_target_simulator_cc
  parameters:
    azimuth: '0'
    center_freq: center_freq
    len_key: '"packet_len"'
    maxoutbuf: max_output_buffer
    minoutbuf: m_min_output_buffer
    position_rx: '0'
    range: value_range
    rcs: 1e22
    rndm_phaseshift: 'True'
    samp_rate: samp_rate
    self_coupling: 'False'
    self_coupling_db: '-10'
    velocity: vel
  states: {}
- name: radar_ts_fft_cc_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    minoutbuf: m_min_output_buffer
    packet_len: packet_len//decimator_fac
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimator_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', radar_ts_fft_cc_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_throttle_0, '0', radar_static_target_simulator_cc_0, '0']
- [radar_estimator_cw_0, Msg out, radar_msg_manipulator_0, Msg in]
- [radar_estimator_cw_0, Msg out, radar_qtgui_scatter_plot_0, Msg in]
- [radar_estimator_cw_0, Msg out, radar_qtgui_time_plot_0, Msg in]
- [radar_msg_manipulator_0, Msg out, radar_print_results_0, Msg in]
- [radar_os_cfar_c_0, Msg out, radar_estimator_cw_0, Msg in]
- [radar_os_cfar_c_0, Msg out, radar_print_results_1, Msg in]
- [radar_signal_generator_cw_c_0, '0', blocks_throttle_0, '0']
- [radar_static_target_simulator_cc_0, '0', blocks_add_xx_0, '1']
- [radar_ts_fft_cc_0, '0', radar_os_cfar_c_0, '0']
- [rational_resampler_xxx_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
