options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: test_usrp_echotimer_cc
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '5800000000'
  states: {}
- name: decim_fac
  id: variable
  parameters:
    value: 2**10
  states: {}
- name: freq_res
  id: variable
  parameters:
    value: samp_rate/packet_len
  states: {}
- name: m_min_output_buffer
  id: variable
  parameters:
    value: packet_len*2
  states: {}
- name: num_delay_samps
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '1000'
    value: '0'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: 2**18
  states: {}
- name: packet_len_red
  id: variable
  parameters:
    value: packet_len/decim_fac
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: wait_to_start
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: m_min_output_buffer
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1.0/decim_fac
    lengthtagname: '"packet_len"'
    minoutbuf: m_min_output_buffer
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decim_fac
    fc: '0'
    fftsize: packet_len//decim_fac
    name: QT GUI Plot
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: radar_estimator_cw_0
  id: radar_estimator_cw
  parameters:
    center_freq: center_freq
  states: {state: disabled}
- name: radar_os_cfar_c_0
  id: radar_os_cfar_c
  parameters:
    len_key: '"packet_len"'
    merge_consecutive: 'True'
    minoutbuf: m_min_output_buffer
    mult_threshold: '15'
    rel_threshold: '0.78'
    samp_compare: '15'
    samp_protect: '0'
    samp_rate: samp_rate//decim_fac
  states: {}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {state: disabled}
- name: radar_signal_generator_cw_c_0
  id: radar_signal_generator_cw_c
  parameters:
    amplitude: '0.5'
    frequency: '10000'
    len_key: '"packet_len"'
    minoutbuf: m_min_output_buffer
    packet_len: packet_len
    samp_rate: samp_rate
  states: {}
- name: radar_usrp_echotimer_cc_0
  id: radar_usrp_echotimer_cc
  parameters:
    antenna_rx: '''J1'''
    antenna_tx: '''J1'''
    args_rx: '''addr=192.168.10.4'''
    args_tx: '''addr=192.168.10.6'''
    center_freq: center_freq
    gain_rx: '0'
    gain_tx: '0'
    lo_offset_rx: samp_rate/2
    minoutbuf: m_min_output_buffer
    num_delay_samps: int(num_delay_samps)
    samp_rate: samp_rate
    wait_rx: wait_to_start
    wait_tx: wait_to_start
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_multiply_conjugate_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', qtgui_sink_x_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', radar_os_cfar_c_0, '0']
- [radar_estimator_cw_0, Msg out, radar_print_results_0, Msg in]
- [radar_os_cfar_c_0, Msg out, radar_estimator_cw_0, Msg in]
- [radar_signal_generator_cw_c_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [radar_signal_generator_cw_c_0, '0', radar_usrp_echotimer_cc_0, '0']
- [radar_usrp_echotimer_cc_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [rational_resampler_xxx_0, '0', blocks_tagged_stream_multiply_length_0, '0']

metadata:
  file_format: 1
